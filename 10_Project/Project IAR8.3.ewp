# IAR project Project IAR8.3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZE ST STM32F407ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx
  ICCARM.CCIncludePath2: ..\02_Arithmetic; ..\04_Board; ..\05_Chip; ..\07_Core; ..\03_Kernel; ..\08_Library\inc; ..\09_User; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\User; ..\Chip
  OBJCOPY.OOCOutputFile: Integrate BL V1.05.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group 02_Arithmetic
    ../02_Arithmetic/: crc.c crc.h IAP.c IAP.h
  group 03_Kernel
    ../03_Kernel/: main.c main.h
  group 04_Board
    ../04_Board/: beep.c beep.h Board_Flash.c Board_Flash.h boot.c boot.h delay.c delay.h DGUS.c DGUS.h FM24CL64.c FM24CL64.h Key.c Key.h led.c led.h RS706.c RS706.h SoftwareSPI.c SoftwareSPI.h SPI_Flash.c SPI_Flash.h sys_led.c sys_led.h
  group 05_Chip
    ../05_Chip/: I2C.c I2C.h spi.c spi.h usart.c usart.h
  group 07_Core
    ../07_Core/: startup_stm32f40_41xxx.s stm32f407xE.icf
  group 08_Library/inc
    ../08_Library/inc/: misc.h stm32f4xx_can.h stm32f4xx_dma.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rtc.h stm32f4xx_spi.h stm32f4xx_tim.h stm32f4xx_usart.h
  group 08_Library/src
    ../08_Library/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group 09_User
    ../09_User/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h
